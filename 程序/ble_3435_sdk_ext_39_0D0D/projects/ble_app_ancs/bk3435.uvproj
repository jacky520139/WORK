# Keil uVision project bk3435.uvproj, settings and files
target BK3435_app (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: bk3435_ble_app +hex
  AfterMake: fromelf --bin --output .\output\app\bk3435_ble_app.bin .\obj\bk3435_ble_app.axf
  AfterMake: .\output\encrypt_app.bat
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c misc: --c99
  c include: .\config;.\app;..\..\libs;..\..\sdk\plactform\core_modules\src;..\..\sdk\plactform\arch;..\..\sdk\plactform\arch\compiler;..\..\sdk\plactform\arch\ll;..\..\sdk\plactform\core_modules\common\api;..\..\sdk\plactform\arch\boot;..\..\sdk\plactform\core_modules\dbg\api;..\..\sdk\plactform\core_modules\rf\api;..\..\sdk\plactform\core_modules\ecc_p256\api;..\..\sdk\plactform\arch\main;..\..\sdk\plactform\core_modules\util;..\..\sdk\plactform\driver\pwm;..\..\sdk\plactform\driver\adc;..\..\sdk\plactform\driver\audio;..\..\sdk\plactform\driver\wdt;..\..\sdk\plactform\driver\rtc;..\..\sdk\plactform\driver\i2c;..\..\sdk\plactform\driver\utc;..\..\sdk\plactform\driver\ir;..\..\sdk\plactform\driver\spi;..\..\sdk\plactform\driver\plf;..\..\sdk\plactform\driver\counter;..\..\sdk\plactform\driver\gpio;..\..\sdk\plactform\driver\intcntl;..\..\sdk\plactform\driver\icu;..\..\sdk\plactform\driver\intc;..\..\sdk\plactform\driver\flash;..\..\sdk\plactform\driver\timer;..\..\sdk\plactform\driver\reg;..\..\sdk\plactform\driver\uart;..\..\sdk\plactform\driver\emi;..\..\sdk\ble_stack\com\rwble;..\..\sdk\ble_stack\com\rwble_hl;..\..\sdk\ble_stack\com\rwble;..\..\sdk\ble_stack\com\rwip\api;..\..\sdk\ble_stack\com\rwble_hl;..\..\sdk\ble_stack\src;..\..\sdk\plactform\reg;..\..\sdk\plactform\driver\syscntl;..\..\sdk\plactform\rom\hci;..\..\sdk\plactform\core_modules\ecc_p256\api;..\..\sdk\ble_stack\inc;..\..\sdk\ble_stack\inc\hci;..\..\sdk\ble_stack\inc\h4tl;..\..\sdk\ble_stack\inc\ke;..\..\sdk\ble_stack\inc\nvds;..\..\sdk\ble_stack\inc\ea;..\..\sdk\ble_stack\inc\em;..\..\sdk\ble_stack\inc\ahi;..\..\sdk\ble_stack\inc\ble\hl\gap\gapc;..\..\sdk\ble_stack\inc\ble\hl\gap\gapm;..\..\sdk\ble_stack\inc\ble\hl\gap\smpc;..\..\sdk\ble_stack\inc\ble\hl\gap\smpm;..\..\sdk\ble_stack\inc\ble\hl\gatt\attc;..\..\sdk\ble_stack\inc\ble\hl\gatt\attm;..\..\sdk\ble_stack\inc\ble\hl\gatt\atts;..\..\sdk\ble_stack\inc\ble\hl\gatt\gattc;..\..\sdk\ble_stack\inc\ble\hl\gatt\gattm;..\..\sdk\ble_stack\inc\ble\hl\l2c\l2cc;..\..\sdk\ble_stack\inc\ble\hl\l2c\l2cm;..\..\sdk\ble_stack\inc\ble\ll\em;..\..\sdk\ble_stack\inc\ble\ll\llc;..\..\sdk\ble_stack\inc\ble\ll\lld;..\..\sdk\ble_stack\inc\ble\ll\llm;..\..\sdk\ble_stack\com\rwip\api;..\..\sdk\ble_stack\inc\ble\hl\gap;..\..\sdk\ble_stack\inc\ble\hl\gatt;..\..\sdk\ble_stack\com\prf;..\..\sdk\ble_stack\com\profiles\dis\diss\src;..\..\sdk\ble_stack\com\profiles\bas\bass\src;..\..\sdk\ble_stack\com\profiles\ancs\ancsc\api;..\..\sdk\ble_stack\com\profiles\ancs\ancsc\src;..\..\sdk\ble_stack\com\profiles\ancs;..\..\sdk\ble_stack\com\profiles\FCC0\api;..\..\sdk\ble_stack\com\profiles\FCC0\src;..\..\sdk\ble_stack\com\profiles\FCC0\util;..\..\sdk\ble_stack\com\profiles\FEE0\api;..\..\sdk\ble_stack\com\profiles\FEE0\src;..\..\sdk\ble_stack\com\profiles\hogp;..\..\sdk\ble_stack\com\profiles\hogp\hogpd\api;..\..\sdk\ble_stack\com\profiles\hogp\hogpd\src;..\..\libs;..\..\sdk\ble_stack\com\profiles\wechat\api;..\..\sdk\ble_stack\com\profiles\wechat\src;.\wechat;..\..\sdk\ble_stack\com\profiles\bas\bass;..\..\sdk\ble_stack\com\profiles\bas\bass\api;..\..\sdk\ble_stack\com\profiles\dis\diss;..\..\sdk\ble_stack\com\profiles\dis\diss\api;..\..\sdk\ble_stack\com\profiles\FFF0\api;..\..\sdk\ble_stack\com\profiles\FFF0;..\..\sdk\ble_stack\com\profiles\oad\api;..\..\sdk\plactform\driver\rc_cal;.\HARDWARE\interface;.\USMART;.\HARDWARE\SC7A21
  asm include: .\src\plf\refip\src\arch\ll
  library: MicroLIB
  scatter file: ..\..\sdk\project_files\gatt_link_app.txt
  link misc: --entry sys_Reset
  group System
    ./app/: arch_main.c
    ../../sdk/project_files/: stack_rom_symbol.txt
    ../../sdk/plactform/arch/boot/: boot_handlers.s boot_vectors.s
  group config
    ./config/: rwip_config.h rwprf_config.h user_config.h
  group ip
    ../../sdk/ble_stack/com/rwble/: rwble.c
    ../../sdk/ble_stack/com/rwble_hl/: rwble_hl.c
    ../../sdk/ble_stack/com/rwip/src/: rwip.c
  group driver
    ../../sdk/plactform/driver/icu/: icu.c
    ../../sdk/plactform/driver/emi/: emi.c
    ../../sdk/plactform/driver/gpio/: gpio.c
    ../../sdk/plactform/driver/intc/: intc.c
    ../../sdk/plactform/driver/uart/: uart.c
    ../../sdk/plactform/driver/wdt/: wdt.c
    ../../sdk/plactform/core_modules/rf/src/: rf_xvr.c
    ../../sdk/plactform/driver/timer/: timer.c
    ../../sdk/plactform/driver/flash/: flash.c
    ../../sdk/plactform/driver/rc_cal/: rc32k_cal.c
    ../../sdk/plactform/driver/pwm/: pwm.c
    ../../sdk/plactform/driver/rtc/: rtc.c
    ../../sdk/plactform/driver/adc/: adc.c
  group profile
    ../../sdk/ble_stack/com/profiles/ancs/ancsc/src/: ancsc.c ancsc_task.c
    ../../sdk/ble_stack/com/profiles/bas/bass/src/: bass.c bass_task.c
    ../../sdk/ble_stack/com/profiles/dis/diss/src/: diss.c diss_task.c
    ../../sdk/ble_stack/com/profiles/FFF0/src/: fff0s.c fff0s_task.c
    ../../sdk/ble_stack/com/profiles/oad/src/: oads.c oads_task.c
    ../../sdk/ble_stack/com/prf/: prf_utils.c prf.c
  group app
    ./app/: app.c app_batt.c app_dis.c app_fff0.c app_oads.c app_ancsc.c app_sec.c app_key.c app_wlist.c app_task.c
  group USMART
    ./USMART/: usart.c usmart.c usmart_config.c usmart_str.c
  group SC7A21
    ./HARDWARE/SC7A21/: SL_SC7A21_Application.c SL_Sc7a21_Driver.c i2c_software.c
  group HARDWARE
    ./HARDWARE/src/: ANO_UART.C app_rtc.c LED.c User_Save.c user_app.c Motor.c
  group lib
    ../../libs/: bk3435_ble_encrypt.lib bk3435_fcc_mode.lib bk3435_pn9_mode.lib
  group README
    ./README/: README.txt
